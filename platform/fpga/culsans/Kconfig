## platform/fpga/culsans/Kconfig
```kconfig
# SPDX-License-Identifier: BSD-2-Clause
config PLATFORM_CULSANS_FPGA
	bool
	select FDT
	select SERIAL_UART8250
	select TIMER_MTIMER
	default y
```
